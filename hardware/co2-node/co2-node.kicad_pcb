# Repository mauravan/autohome (continued)

## KiCad design hardware/co2-node/co2-node.kicad_pcb (continued)

Board: 2 copper layers, 97 parts (1 on the bottom side), 59 nets, no tracks yet.

File hardware/co2-node/bom/BOM.csv:

"Reference","Value","Footprint","MPN","Manufacturer","QUANTITY","DNP"
"BT1","Keystone-1043","co2-node:Keystone-1043","1043","Keystone","1",""
"C20","1u","Capacitor_SMD:C_0603_1608Metric","CL10B105KP8NNNC","Samsung","1",""
"C21","10u","Capacitor_SMD:C_0603_1608Metric","CL10A106KP8NNNC","Samsung","1",""
"C22","10u","Capacitor_SMD:C_0603_1608Metric","CL10A106KP8NNNC","Samsung","1",""
"C23","0.1u","Capacitor_SMD:C_0603_1608Metric","CL10B104KP8NNNC","Samsung","1",""
"C24","1u","Capacitor_SMD:C_0603_1608Metric","CL10B105KP8NNNC","Samsung","1",""
"C25","10u","Capacitor_SMD:C_0603_1608Metric","CL10A106KP8NNNC","Samsung","1",""
"C26","0.1u","Capacitor_SMD:C_0603_1608Metric","CL10B104KP8NNNC","Samsung","1",""
"C27","10u","Capacitor_SMD:C_0603_1608Metric","CL10A106KP8NNNC","Samsung","1",""
"C28","0.1u","Capacitor_SMD:C_0603_1608Metric","CL10B104KP8NNNC","Samsung","1",""
"C29","100n","Capacitor_SMD:C_0603_1608Metric","CL10B104KP8NNNC","Samsung","1",""
"C40","10u","Capacitor_SMD:C_0603_1608Metric","CL10A106KP8NNNC","Samsung","1",""
"C41","1u","Capacitor_SMD:C_0603_1608Metric","CL10B105KP8NNNC","Samsung","1",""
"C42","0.1u","Capacitor_SMD:C_0603_1608Metric","CL10B104KP8NNNC","Samsung","1",""
"C43","100n","Capacitor_SMD:C_0603_1608Metric","CL10B104KP8NNNC","Samsung","1",""
"C50","1u","Capacitor_SMD:C_0603_1608Metric","CL10B105KP8NNNC","Samsung","1",""
"C51","10u","Capacitor_SMD:C_0603_1608Metric","CL10A106KP8NNNC","Samsung","1",""
"C60","1u","Capacitor_SMD:C_0402_1005Metric","CL05B105KP5NNNC","Samsung","1",""
"C61","0.1u","Capacitor_SMD:C_0402_1005Metric","CL05B104KP5NNNC","Samsung","1",""
"C62","1u","Capacitor_SMD:C_0402_1005Metric","CL05B105KP5NNNC","Samsung","1",""
"C63","1u","Capacitor_SMD:C_0402_1005Metric","CL05B105KP5NNNC","Samsung","1",""
"C64","1u","Capacitor_SMD:C_0402_1005Metric","CL05B105KP5NNNC","Samsung","1",""
"C65","1u","Capacitor_SMD:C_0402_1005Metric","CL05B105KP5NNNC","Samsung","1",""
"C66","10u","Capacitor_SMD:C_0603_1608Metric","CL10A106KP8NNNC","Samsung","1",""
"C67","0.1u","Capacitor_SMD:C_0402_1005Metric","CL05B104KP5NNNC","Samsung","1",""
"C68","1u","Capacitor_SMD:C_0402_1005Metric","CL05B105KP5NNNC","Samsung","1",""
"C69","100p-NC","Capacitor_SMD:C_0402_1005Metric","-","-","1","DNP"
"C70","1u","Capacitor_SMD:C_0402_1005Metric","CL05B105KP5NNNC","Samsung","1",""
"C71","1u","Capacitor_SMD:C_0402_1005Metric","CL05B105KP5NNNC","Samsung","1",""
"C72","1u","Capacitor_SMD:C_0402_1005Metric","CL05B105KP5NNNC","Samsung","1",""
"D1","USBLC6-2SC6","Package_TO_SOT_SMD:SOT-23-6","USBLC6-2SC6","ST","1",""
"D20","CHG-GRN","LED_SMD:LED_0603_1608Metric","LTST-C190KGKT","Lite-On","1",""
"D21","B5819W","Diode_SMD:D_SOD-323","B5819W","Diodes Inc","1",""
"D22","B5819W","Diode_SMD:D_SOD-323","B5819W","Diodes Inc","1",""
"D23","B5819W","Diode_SMD:D_SOD-323","B5819W","Diodes Inc","1",""
"F1","0.75A","Fuse:Fuse_0603_1608Metric","MF-PSMF075X-2","Bourns","1",""
"F2","2A","Fuse:Fuse_1206_3216Metric","MF-PSMF200X-2","Bourns","1",""
"FB50","600R@100MHz","Inductor_SMD:L_0603_1608Metric","BLM18PG601SN1D","Murata","1",""
"H1","M2.5","MountingHole:MountingHole_2.7mm_M2.5_Pad","-","-","1",""
"H2","M2.5","MountingHole:MountingHole_2.7mm_M2.5_Pad","-","-","1",""
"H3","M2.5","MountingHole:MountingHole_2.7mm_M2.5_Pad","-","-","1",""
"H4","M2.5","MountingHole:MountingHole_2.7mm_M2.5_Pad","-","-","1",""
"IC-SCD?","SCD41-D-R2","Sensor:Sensirion_SCD4x-1EP_10.1x10.1mm_P1.25mm_EP4.8x4.8mm","SCD41-D-R2","Sensirion","1",""
"J1","USB-C-16P","Connector_USB:USB_C_Receptacle_HCTL_HC-TYPE-C-16P-01A","TYPE-C-16P","G-Switch","1",""
"J2","FPC-24-0.5mm","Connector_FFC-FPC:Hirose_FH12-24S-0.5SH_1x24-1MP_P0.50mm_Horizontal","FH12-24S-0.5SH","Hirose","1",""
"L1","10uH","Inductor_SMD:L_0603_1608Metric","LQH3NPN100MJRL","Murata","1",""
"Q1","AO3402","Package_TO_SOT_SMD:SOT-23","AO3402","Alpha&Omega","1",""
"Q2","AO3401A","Package_TO_SOT_SMD:SOT-23","AO3401A","Alpha&Omega","1",""
"Q3","AO3401A","Package_TO_SOT_SMD:SOT-23","AO3401A","Alpha&Omega","1",""
"Q4","BSS138","Package_TO_SOT_SMD:SOT-23","BSS138","Onsemi","1",""
"R1","100K","Resistor_SMD:R_0402_1005Metric","RC0402-100K-1%","Yageo","1",""
"R2","3R","Resistor_SMD:R_0603_1608Metric","RC0603-3R-1%","Yageo","1",""
"R10","5.1k","Resistor_SMD:R_0603_1608Metric","RC0603-5.1k-1%","Yageo","1",""
"R11","5.1k","Resistor_SMD:R_0603_1608Metric","RC0603-5.1k-1%","Yageo","1",""
"R12","22R","Resistor_SMD:R_0603_1608Metric","RC0603-22R-1%","Yageo","1",""
"R13","22R","Resistor_SMD:R_0603_1608Metric","RC0603-22R-1%","Yageo","1",""
"R20","1.78k","Resistor_SMD:R_0603_1608Metric","RC0603-1.78k-1%","Yageo","1",""
"R21","DNP","Resistor_SMD:R_0603_1608Metric","-","-","1","DNP"
"R22","2.2k","Resistor_SMD:R_0603_1608Metric","RC0603-2.2k-1%","Yageo","1",""
"R23","10k","Resistor_SMD:R_0603_1608Metric","RC0603-10k-1%","Yageo","1",""
"R24","100R","Resistor_SMD:R_0603_1608Metric","RC0603-100R-1%","Yageo","1",""
"R25","1k","Resistor_SMD:R_0603_1608Metric","RC0603-1k-1%","Yageo","1",""
"R27","100k","Resistor_SMD:R_0603_1608Metric","RC0603-100k-1%","Yageo","1",""
"R28","100k","Resistor_SMD:R_0603_1608Metric","RC0603-100k-1%","Yageo","1",""
"R29","100k","Resistor_SMD:R_0603_1608Metric","RC0603-100k-1%","Yageo","1",""
"R30","1M","Resistor_SMD:R_0603_1608Metric","RC0603-1M-1%","Yageo","1",""
"R31","1M","Resistor_SMD:R_0603_1608Metric","RC0603-1M-1%","Yageo","1",""
"R32","1k","Resistor_SMD:R_0603_1608Metric","RC0603-1k-1%","Yageo","1",""
"R40","10k","Resistor_SMD:R_0603_1608Metric","RC0603-10k-1%","Yageo","1",""
"R41","10k","Resistor_SMD:R_0603_1608Metric","RC0603-10k-1%","Yageo","1",""
"R42","10k","Resistor_SMD:R_0603_1608Metric","RC0603-10k-1%","Yageo","1",""
"R43","10k","Resistor_SMD:R_0603_1608Metric","RC0603-10k-1%","Yageo","1",""
"R50","10k","Resistor_SMD:R_0603_1608Metric","RC0603-10k-1%","Yageo","1",""
"R51","10k","Resistor_SMD:R_0603_1608Metric","RC0603-10k-1%","Yageo","1",""
"R60","100R","Resistor_SMD:R_0402_1005Metric","RC0402-100R-1%","Yageo","1",""
"R61","100R","Resistor_SMD:R_0402_1005Metric","RC0402-100R-1%","Yageo","1",""
"R62","100R","Resistor_SMD:R_0402_1005Metric","RC0402-100R-1%","Yageo","1",""
"R63","100R","Resistor_SMD:R_0402_1005Metric","RC0402-100R-1%","Yageo","1",""
"R64","100R","Resistor_SMD:R_0402_1005Metric","RC0402-100R-1%","Yageo","1",""
"R65","100R","Resistor_SMD:R_0402_1005Metric","RC0402-100R-1%","Yageo","1",""
"R66","5.1k","Resistor_SMD:R_0402_1005Metric","RC0402-5.1k-1%","Yageo","1",""
"RT1","10k-B3950","Resistor_SMD:R_0603_1608Metric","NCP18XH103FDBRB","Murata","1",""
"SW1","BOOT","Button_Switch_SMD:SW_Push_1P1T_NO_CK_KMR2","TL3305","E-Switch","1",""
"SW2","RESET","Button_Switch_SMD:SW_Push_1P1T_NO_CK_KMR2","TL3305","E-Switch","1",""
"TP1","3V3","TestPoint:TestPoint_Pad_1.0x1.0mm","-","-","1",""
"TP2","GND","TestPoint:TestPoint_Pad_1.0x1.0mm","-","-","1",""
"TP3","BAT+","TestPoint:TestPoint_Pad_1.0x1.0mm","-","-","1",""
"TP4","P3V3","TestPoint:TestPoint_Pad_1.0x1.0mm","-","-","1",""
"TP5","RESET_N","TestPoint:TestPoint_Pad_1.0x1.0mm","-","-","1",""
"TP6","BOOT_N","TestPoint:TestPoint_Pad_1.0x1.0mm","-","-","1",""
"TP7","I2C_SCL","TestPoint:TestPoint_Pad_1.0x1.0mm","-","-","1",""
"TP8","PWR_EN","TestPoint:TestPoint_Pad_1.0x1.0mm","-","-","1",""
"U1","BQ24074RGTR","co2-node:BQ24074-VQFN-16","BQ24074RGTR","TI","1",""
"U2","TPS7A2633DRVR","co2-node:TPS7A26-WSON-6","TPS7A2633DRVR","TI","1",""
"U3","DW01A","Package_TO_SOT_SMD:SOT-23-6","DW01A","H&M Semi","1",""
"U4","FS8205A","Package_SO:TSSOP-8_4.4x3mm_P0.65mm","FS8205A","Fortune Semi","1",""
"U10","ESP32-C3-MINI-1-N4","RF_Module:ESP32-C6-MINI-1","ESP32-C3-MINI-1-N4","Espressif","1",""
LBL1,AH-CO2-1,,-,-,1,
DNC-PAD,DNC-float,,-,-,1,
